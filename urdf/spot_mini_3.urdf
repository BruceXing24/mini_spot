Commit message: mini_spot train works! first time

File: urdf/spot_mini_3.urdf (robot description, URDF)
Before this commit: robot spot_mini_3, 21 links, 20 joints
Links:
- link base_link: mass 0.6520422640185799 -> 1.5
